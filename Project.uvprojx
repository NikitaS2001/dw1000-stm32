# Keil uVision project Project.uvprojx, settings and files
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dwm1000 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210E_EVAL, RX_BUFFER_SIZE=512, TX_BUFFER_SIZE=512
  c include: Source\;Libraries\CMSIS\CM3\CoreSupport;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\STM32F10x_StdPeriph_Driver\inc;Utilities\STM32_EVAL;Utilities\STM32_EVAL\Common;Utilities\STM32_EVAL\STM3210E_EVAL;Source\3rdparty;Source\3rdparty\stm_lib;Source\3rdparty\deca_lib;Source\3rdparty\ros_lib;Source\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group at24
    Source/device/at24c16/: AT24C02.c AT24C02.h
  group comm
    ./Source/comm/: comm.cpp
  group dwm1000
    ./Source/device/dwm1000/: dwm1000.o
    Source/device/dwm1000/: dwm1000.h
  group kalman
    Source/kalman/: kalman.c kalman.h
  group main
    ./Source/: main.c
  group math
    Source/math/: matrix.c matrix.h vector.c vector.h
  group memory
    ./Source/device/memory/: flash.c
  group shell
    ./Source/shell/: shell.cpp
  group deca_lib
    Source/3rdparty/deca_lib/: deca_device.c deca_device_api.h deca_mutex.c deca_param_types.h deca_params_init.c deca_port.c deca_port.h deca_range_tables.c deca_regs.h deca_sleep.c deca_sleep.h deca_spi.c deca_spi.h deca_types.h deca_version.h
  group ros_lib
    Source/3rdparty/ros_lib/: duration.cpp ringbuf.c ringbuf.h ros.h STM32Hardware.cpp STM32Hardware.h time.cpp
  group stm_lib
    Source/3rdparty/stm_lib/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c
  group StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_EVAL
    Utilities/STM32_EVAL/: stm32_eval.c
    Utilities/STM32_EVAL/Common/: stm32_eval_spi_sd.c stm32_eval_i2c_ee.c stm32_eval_i2c_tsensor.c stm32_eval_sdio_sd.c stm32_eval_spi_flash.c
    Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_fsmc_sram.c stm3210e_eval_fsmc_nand.c stm3210e_eval_fsmc_nor.c
  group MDK-ARM
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s startup_stm32f10x_hd_vl.s
software components: CMSIS:CORE 5.3.0
